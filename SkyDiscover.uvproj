# Keil uVision project SkyDiscover.uvproj, settings and files
target SkyDiscover (ARM-ADS)
  device: TM4C1233H6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: SkyDiscover
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR TARGET_IS_BLIZZARD_RA2 UART_BUFFERED
  c include: ..\SkyDiscover;C:\StellarisWare
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group UserCode
    ./: startup_TM4C123.s main.cpp
    C:/Keil/ARM/Startup/TI/TM4C123/: system_TM4C123.c
  group Libraries
    C:/StellarisWare/driverlib/: adc.c can.c comp.c cpu.c eeprom.c epi.c ethernet.c fan.c flash.c fpu.c gpio.c hibernate.c i2c.c i2s.c interrupt.c lpc.c mpu.c peci.c pwm.c qei.c ssi.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group Ultis
    C:/StellarisWare/utils/: uartstdio.c
    ./drivers/: buttons.c rgb.c
